# This is just placeholder for possible modifications

IMAGE_INSTALL_append = " ${XT_GUEST_INSTALL}"
